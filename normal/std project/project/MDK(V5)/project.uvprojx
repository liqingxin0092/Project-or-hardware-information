# Keil uVision project project.uvprojx, settings and files
target Project (6190000::V6.19::ARMCLANG)
  device: GD32F407VE GigaDevice
  pack: GigaDevice.GD32F4xx_DFP.3.2.0
  cpu: IRAM(0x20000000,0x020000) IRAM2(0x10000000,0x010000) IROM(0x08000000,0x080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: project +hex
  c flags: Optim=4 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_STDPERIPH_DRIVER,GD32F407,__TARGET_FPU_VFP
  c include: ..\..\app;..\..\bsp;..\..\libraries\CMSIS\GD\GD32F4xx\Include;..\..\libraries\CMSIS\GD\GD32F4xx;..\..\libraries\GD32F4xx_standard_peripheral\Include;..\..\libraries\CMSIS;..\..\libraries\CMSIS\GD\GD32F4xx\Source\ARM;..\..\board;..\..\module\soft_timer;..\..\module\ringbuffer;..\..\module\buzzer;..\..\bsp\spi;..\..\bsp\uart;..\..\bsp\rtc;..\..\bsp\led;..\..\mine\inc;..\..\bsp\USART;..\..\bsp\adc;..\..\bsp\OLED;..\..\bsp\sd;..\..\module\Fatfs\source;..\..\module\FreeRTOS\include;..\..\module\FreeRTOS\portable\GCC\ARM_CM4F
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  scatter file: .\project.sct
  group APP
    ../../app/: main.c FreeRTOSConfig.h my_freertos.c my_freertos.h
  group STD_Driver
    ../../libraries/GD32F4xx_standard_peripheral/Source/: gd32f4xx_adc.c gd32f4xx_can.c gd32f4xx_crc.c gd32f4xx_ctc.c gd32f4xx_dac.c gd32f4xx_dbg.c gd32f4xx_dci.c gd32f4xx_dma.c gd32f4xx_enet.c gd32f4xx_exmc.c gd32f4xx_exti.c gd32f4xx_fmc.c gd32f4xx_fwdgt.c gd32f4xx_gpio.c gd32f4xx_i2c.c gd32f4xx_ipa.c gd32f4xx_iref.c gd32f4xx_misc.c gd32f4xx_pmu.c gd32f4xx_rcu.c gd32f4xx_rtc.c gd32f4xx_sdio.c gd32f4xx_spi.c gd32f4xx_syscfg.c gd32f4xx_timer.c gd32f4xx_tli.c gd32f4xx_trng.c gd32f4xx_usart.c gd32f4xx_wwdgt.c
  group STARTUP
    ../../libraries/CMSIS/GD/GD32F4xx/Source/ARM/: startup_gd32f407_427.s
  group MODULE
    ../../module/soft_timer/: soft_timer.c
    ../../module/ringbuffer/: ringbuffer.c
  group CMSIS
    ../../libraries/CMSIS/GD/GD32F4xx/Source/: system_gd32f4xx.c
  group Board
    ../../board/: board.c
  group BSP
    ../../bsp/spi/: spi_flash.c
    ../../bsp/uart/: bsp_uart.c
    ../../bsp/rtc/: rtc.c
    ../../bsp/led/: bsp_led.c
    ../../bsp/USART/: usart.c
    ../../bsp/adc/: bsp_adc.c
    ../../bsp/OLED/: oled.c
    ../../bsp/sd/: drv_sdcard.c
  group mine
    ../../mine/src/: sdio.c ad.c
  group DOC
    ../../: README.md
  group Fatfs
    ../../module/Fatfs/source/: diskio.c ff.c ffconf.h ffsystem.c ffunicode.c
  group freertos_core
    ../../module/FreeRTOS/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group freertos_port
    ../../module/FreeRTOS/portable/MemMang/: heap_4.c
    ../../module/FreeRTOS/portable/GCC/ARM_CM4F/: port.c
