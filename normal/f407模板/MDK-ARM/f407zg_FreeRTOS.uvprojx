# Keil uVision project f407zg_FreeRTOS.uvprojx, settings and files
target f407zg_FreeRTOS (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F407ZGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.0
  cpu: IRAM(0x20000000-0x2001BFFF) IRAM2(0x2001C000-0x2001FFFF) IROM(0x8000000-0x80FFFFF)  CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: f407zg_FreeRTOS +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F407xx
  c include: ../Core/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Include;../FreeRTOS/include;../FreeRTOS/portable/RVDS/ARM_CM4F;..\Drivers\CMSIS\f407_include;..\USMART;..\Hardware\GBK_LibDrive;..\Hardware\SPI;..\Hardware\KEY;..\Hardware\W25QXX;..\Hardware\LED;..\Hardware\TOUCH;..\Hardware\TF-Card;..\Hardware\FATFS\source;..\Drivers\MALLOC;..\Hardware\FATFS\exfuns
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x1c000
  memory RVCT10: RAM 0x2001c000 size 0x4000
  group Application/MDK-ARM
    ./: startup_stm32f407xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c usart.c stm32f4xx_it.c stm32f4xx_hal_msp.c my_freertos.c 3.2_LCD.c fsmc.c delay.c FONT.c pic.c
    ../Core/Inc/: FreeRTOSConfig.h stm32f4xx_hal_conf.h
    ../Hardware/TF-Card/: TF-card.c
    ../Drivers/MALLOC/: malloc.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_sram.c stm32f4xx_ll_fsmc.c stm32f4xx_hal_spi.c stm32f4xx_ll_spi.c stm32f4xx_hal_sd.c stm32f4xx_ll_sdmmc.c stm32f4xx_hal_mmc.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group FreeROTS_CORE
    ../FreeRTOS/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group FreeRTOS_PORT
    ../FreeRTOS/portable/MemMang/: heap_4.c
    ../FreeRTOS/portable/RVDS/ARM_CM4F/: port.c
  group USMART
    ../USMART/: usmart.c usmart_config.c usmart_port.c usmart_str.c
  group HARDWARE
    ../Hardware/GBK_LibDrive/: GBK_LibDrive.c GBK_LibDrive.h
    ../Hardware/KEY/: key.c key.h
    ../Hardware/LED/: led.h led.c
    ../Hardware/SPI/: spi.c spi.h
    ../Hardware/TOUCH/: touch.c touch.h
    ../Hardware/W25QXX/: w25qxx.c w25qxx.h
  group FATFS
    ../Hardware/FATFS/source/: diskio.c ff.c ffunicode.c ffsystem.c
    ../Hardware/FATFS/exfuns/: exfuns.c fattester.c
software components: CMSIS:CORE 4.3.0
