# Keil uVision project project.uvprojx, settings and files
target base_project (6190000::V6.19::ARMCLANG)
  device: STM32H750VBTx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.3.0.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x24000000,0x00080000) IROM(0x08000000,0x00020000) XRAM(0x30000000,0x00048000) XRAM2(0x38000000,0x00010000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: project +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=3 v6LangP=5 wLevel=3
  c define: USE_HAL_DRIVER,STM32H750xx
  c misc: -Wno-typedef-redefinition -Wno-invalid-source-encoding -Wno-return-type
  c include: ..\Driver\STM32H7xx_HAL_Driver\Inc;..\Driver\CMSIS\h750_Include;..\Driver\CMSIS\Include;..\Peripheral\SDMMC;..\User;..\Sys\Delay;..\Sys\USMART;..\Sys\Uart;..\FreeRTOS\portable\RVDS\ARM_CM7;..\FreeRTOS\include;..\Peripheral\sd card;..\Peripheral\W25Q64;..\Peripheral\MPU;..\Midware\FATFS\exfuns;..\Midware\FATFS\source;..\Peripheral\LCD;..\Sys\MALLOC;..\Sys\sys;..\Peripheral\SDMMC;..\Midware\PICTURE;..\Midware\soft_timer;..\FreeRTOS\portable\GCC\ARM_CM7
  library: MicroLIB
  memory RVCT1: ROM 0x90000000 size 0xa0000
  memory RVCT5: ROM 0x8000000 size 0x20000
  memory RVCT6: RAM 0x30000000 size 0x48000
  memory RVCT7: RAM 0x38000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x80000
  group Startup
    ./: startup_stm32h750xx.s
  group User
    ../User/: main.c stm32h7xx_it.c stm32h7xx_it.h system_stm32h7xx.c btim.c my_freertos.c stm32h7xx_hal_conf.h
  group Driver/HAL
    ../Driver/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal.c stm32h7xx_hal_cortex.c stm32h7xx_hal_dma.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_exti.c stm32h7xx_hal_flash.c stm32h7xx_hal_flash_ex.c stm32h7xx_hal_gpio.c stm32h7xx_hal_hsem.c stm32h7xx_hal_i2c.c stm32h7xx_hal_i2c_ex.c stm32h7xx_hal_mdma.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal_qspi.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_tim.c stm32h7xx_hal_tim_ex.c stm32h7xx_hal_uart.c stm32h7xx_hal_uart_ex.c stm32h7xx_hal_sd.c stm32h7xx_hal_sd_ex.c stm32h7xx_ll_delayblock.c stm32h7xx_ll_sdmmc.c stm32h7xx_hal_spi.c stm32h7xx_hal_spi_ex.c
  group Peripheral
    ../Peripheral/W25Q64/: qspi_w25q64.c
    ../Peripheral/MPU/: mpu.c
  group SYS
    ../Sys/Delay/: delay.c delay.h
    ../Sys/Uart/: usart.c usart.h
    ../Sys/sys/: sys.c
    ../Sys/MALLOC/: malloc.c
    ../Sys/HardFaultHandlerMDK/: HardFaultHandler.S SEGGER_HardFaultHandler.c
  group USMART
    ../Sys/USMART/: usmart.c usmart_config.c usmart_port.c usmart_str.c
  group RTOS_CORE
    ../FreeRTOS/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group RTOS_PORT
    ../FreeRTOS/portable/MemMang/: heap_4.c
    ../FreeRTOS/portable/GCC/ARM_CM7/: port.c
  group Fatfs
    ../Midware/FATFS/source/: diskio.c ff.c ffsystem.c ffconf.h
    ../Midware/FATFS/exfuns/: exfuns.c fattester.c
  group EX_FLASH_CODE
    ../Peripheral/LCD/: lcd.c lcd_fonts.c
    ../Peripheral/SDMMC/: sdmmc_sdcard.c
  group PICTURE
    ../Midware/PICTURE/: bmp.c gif.c piclib.c tjpgd.c
    ../bmp_picture/: weixin.c
  group soft_timer
    ../Midware/soft_timer/: soft_timer.c
software components: Compiler:Event Recorder 1.5.1
