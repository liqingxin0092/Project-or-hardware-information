# Keil uVision project Led_Reg.uvprojx, settings and files
target LED_Reg (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Led_Reg +hex
  AfterMake: fromelf --text -a -c --output=Objects\LED_REG.dis Objects\LED_REG.axf
  c flags: Optim=4 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: ..\CPU;..\Driver;..\Main
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Cpu
    ../CPU/: startup_stm32f10x_hd.s
