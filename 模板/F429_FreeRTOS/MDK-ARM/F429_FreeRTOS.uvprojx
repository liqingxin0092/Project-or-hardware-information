# Keil uVision project F429_FreeRTOS.uvprojx, settings and files
target F429_FreeRTOS (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F429BITx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.0
  cpu: IRAM(0x20000000,0x00030000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00200000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: F429_FreeRTOS +hex
  c flags: Optim=1 oTime=1 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_FULL_LL_DRIVER,USE_HAL_DRIVER,STM32F429xx,STM32F4
  c misc: --no-multibyte-chars
  c include: ../Core/Inc;..\Drivers\CMSIS\f429_include;..\Drivers\CMSIS\Include;..\Drivers\STM32F4xx_HAL_Driver\Inc;..\FreeRTOS\include;..\FreeRTOS\portable\RVDS\ARM_CM4F;..\Drivers\STM32F4xx_HAL_Driver\Inc;..\USMART;..\Hardware;..\Hardware\SPI;..\Hardware\TEXT;..\Hardware\TF-Card;..\Hardware\FATFS\exfuns;..\Hardware\FATFS\source;..\PICTURE;..\Hardware\STMFLASH;..\Hardware\LVGL\GUI;..\Hardware\LVGL\GUI\lvgl;..\Hardware\LVGL\GUI\lvgl\src;..\Hardware\LVGL\GUI\lvgl\examples\porting;..\Hardware\LVGL\GUI_APP\demos;..\Hardware\LVGL\GUI_APP\demos\stress;..\Hardware\LVGL\GUI_APP\demos\music
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Application/MDK-ARM
    ./: startup_stm32f429xx.s
  group Application/User/Core
    ../Core/Src/: main.c stm32f4xx_it.c stm32f4xx_hal_msp.c my_freertos.c delay.c usart.c ltdc.c FONT.c fmc.c SDRAM.c gpio.c btim.c touch.c malloc.c
    ../Core/Inc/: stm32f4xx_hal_conf.h FreeRTOSConfig.h
    ../Hardware/: 2.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_ltdc.c stm32f4xx_hal_ltdc_ex.c stm32f4xx_hal_dsi.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_ll_rcc.c stm32f4xx_ll_utils.c stm32f4xx_ll_exti.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_ll_tim.c stm32f4xx_ll_dma.c stm32f4xx_ll_usart.c stm32f4xx_hal_uart.c stm32f4xx_hal_sdram.c stm32f4xx_ll_fmc.c stm32f4xx_hal_nand.c stm32f4xx_hal_spi.c stm32f4xx_ll_spi.c stm32f4xx_hal_sd.c stm32f4xx_ll_sdmmc.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group FreeRTOS_PORT
    ../FreeRTOS/portable/MemMang/: heap_4.c
    ../FreeRTOS/portable/RVDS/ARM_CM4F/: port.c
  group FreeRTOS_CORE
    ../FreeRTOS/: event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c croutine.c
  group USMART
    ../USMART/: usmart.c usmart_config.c usmart_port.c usmart_str.c
  group Hardware
    ../Hardware/: fsmc_nand.c w25qxx.c ftl.c
    ../Hardware/SPI/: spi.c
    ../Hardware/TEXT/: fonts.c text.c
    ../Hardware/TF-Card/: TF-card.c
    ../Hardware/FATFS/exfuns/: exfuns.c fattester.c myffunicode.c
    ../Hardware/FATFS/source/: diskio.c ff.c ffsystem.c
    ../Hardware/STMFLASH/: stmflash.c
  group Picture
    ../PICTURE/: bmp.c gif.c piclib.c tjpgd.c
  group lvgl/example/porting
    ../Hardware/LVGL/GUI/lvgl/examples/porting/: lv_port_disp_template.c lv_port_indev_template.c
  group lvgl/src/core
    ../Hardware/LVGL/GUI/lvgl/src/core/: lv_disp.c lv_event.c lv_group.c lv_indev.c lv_indev_scroll.c lv_obj.c lv_obj_class.c lv_obj_draw.c lv_obj_pos.c lv_obj_scroll.c lv_obj_style.c lv_obj_style_gen.c lv_obj_tree.c lv_refr.c lv_theme.c
  group lvgl/src/draw
    ../Hardware/LVGL/GUI/lvgl/src/draw/sw/: lv_draw_sw.c lv_draw_sw_arc.c lv_draw_sw_blend.c lv_draw_sw_dither.c lv_draw_sw_gradient.c lv_draw_sw_img.c lv_draw_sw_letter.c lv_draw_sw_line.c lv_draw_sw_polygon.c lv_draw_sw_rect.c
    ../Hardware/LVGL/GUI/lvgl/src/draw/: lv_draw.c lv_draw_arc.c lv_draw_img.c lv_draw_label.c lv_draw_line.c lv_draw_mask.c lv_draw_rect.c lv_draw_triangle.c lv_img_buf.c lv_img_cache.c lv_img_decoder.c
  group lvgl/src/extra
    ../Hardware/LVGL/GUI/lvgl/src/extra/layouts/flex/: lv_flex.c
    ../Hardware/LVGL/GUI/lvgl/src/extra/layouts/grid/: lv_grid.c
    ../Hardware/LVGL/GUI/lvgl/src/extra/libs/bmp/: lv_bmp.c
    ../Hardware/LVGL/GUI/lvgl/src/extra/libs/ffmpeg/: lv_ffmpeg.c
    ../Hardware/LVGL/GUI/lvgl/src/extra/libs/freetype/: lv_freetype.c
    ../Hardware/LVGL/GUI/lvgl/src/extra/libs/fsdrv/: lv_fs_fatfs.c lv_fs_posix.c lv_fs_stdio.c lv_fs_win32.c
    ../Hardware/LVGL/GUI/lvgl/src/extra/libs/gif/: gifdec.c lv_gif.c
    ../Hardware/LVGL/GUI/lvgl/src/extra/libs/png/: lodepng.c lv_png.c
    ../Hardware/LVGL/GUI/lvgl/src/extra/libs/qrcode/: lv_qrcode.c qrcodegen.c
    ../Hardware/LVGL/GUI/lvgl/src/extra/libs/rlottie/: lv_rlottie.c
    ../Hardware/LVGL/GUI/lvgl/src/extra/libs/sjpg/: lv_sjpg.c tjpgd.c
    ../Hardware/LVGL/GUI/lvgl/src/extra/others/gridnav/: lv_gridnav.c
    ../Hardware/LVGL/GUI/lvgl/src/extra/others/monkey/: lv_monkey.c
    ../Hardware/LVGL/GUI/lvgl/src/extra/others/snapshot/: lv_snapshot.c
    ../Hardware/LVGL/GUI/lvgl/src/extra/themes/basic/: lv_theme_basic.c
    ../Hardware/LVGL/GUI/lvgl/src/extra/themes/default/: lv_theme_default.c
    ../Hardware/LVGL/GUI/lvgl/src/extra/themes/mono/: lv_theme_mono.c
    ../Hardware/LVGL/GUI/lvgl/src/extra/widgets/animimg/: lv_animimg.c
    ../Hardware/LVGL/GUI/lvgl/src/extra/widgets/calendar/: lv_calendar.c lv_calendar_header_arrow.c lv_calendar_header_dropdown.c
    ../Hardware/LVGL/GUI/lvgl/src/extra/widgets/chart/: lv_chart.c
    ../Hardware/LVGL/GUI/lvgl/src/extra/widgets/colorwheel/: lv_colorwheel.c
    ../Hardware/LVGL/GUI/lvgl/src/extra/widgets/imgbtn/: lv_imgbtn.c
    ../Hardware/LVGL/GUI/lvgl/src/extra/widgets/keyboard/: lv_keyboard.c
    ../Hardware/LVGL/GUI/lvgl/src/extra/widgets/led/: lv_led.c
    ../Hardware/LVGL/GUI/lvgl/src/extra/widgets/list/: lv_list.c
    ../Hardware/LVGL/GUI/lvgl/src/extra/widgets/menu/: lv_menu.c
    ../Hardware/LVGL/GUI/lvgl/src/extra/widgets/meter/: lv_meter.c
    ../Hardware/LVGL/GUI/lvgl/src/extra/widgets/msgbox/: lv_msgbox.c
    ../Hardware/LVGL/GUI/lvgl/src/extra/widgets/span/: lv_span.c
    ../Hardware/LVGL/GUI/lvgl/src/extra/widgets/spinbox/: lv_spinbox.c
    ../Hardware/LVGL/GUI/lvgl/src/extra/widgets/spinner/: lv_spinner.c
    ../Hardware/LVGL/GUI/lvgl/src/extra/widgets/tabview/: lv_tabview.c
    ../Hardware/LVGL/GUI/lvgl/src/extra/widgets/tileview/: lv_tileview.c
    ../Hardware/LVGL/GUI/lvgl/src/extra/widgets/win/: lv_win.c
    ../Hardware/LVGL/GUI/lvgl/src/extra/: lv_extra.c
  group lvgl/src/font
    ../Hardware/LVGL/GUI/lvgl/src/font/: lv_font.c lv_font_dejavu_16_persian_hebrew.c lv_font_fmt_txt.c lv_font_loader.c lv_font_montserrat_8.c lv_font_montserrat_10.c lv_font_montserrat_12.c lv_font_montserrat_12_subpx.c lv_font_montserrat_14.c lv_font_montserrat_16.c lv_font_montserrat_18.c lv_font_montserrat_20.c lv_font_montserrat_22.c lv_font_montserrat_24.c lv_font_montserrat_26.c lv_font_montserrat_28.c lv_font_montserrat_28_compressed.c lv_font_montserrat_30.c lv_font_montserrat_32.c lv_font_montserrat_34.c lv_font_montserrat_36.c lv_font_montserrat_38.c lv_font_montserrat_40.c lv_font_montserrat_42.c lv_font_montserrat_44.c lv_font_montserrat_46.c lv_font_montserrat_48.c lv_font_simsun_16_cjk.c lv_font_unscii_8.c lv_font_unscii_16.c
  group lvgl/src/gpu
    ../Hardware/LVGL/GUI/lvgl/src/draw/sdl/: lv_draw_sdl.c lv_draw_sdl_arc.c lv_draw_sdl_bg.c lv_draw_sdl_composite.c lv_draw_sdl_img.c lv_draw_sdl_label.c lv_draw_sdl_line.c lv_draw_sdl_mask.c lv_draw_sdl_polygon.c lv_draw_sdl_rect.c lv_draw_sdl_stack_blur.c lv_draw_sdl_texture_cache.c lv_draw_sdl_utils.c
    ../Hardware/LVGL/GUI/lvgl/src/draw/stm32_dma2d/: lv_gpu_stm32_dma2d.c
  group lvgl/src/hal
    ../Hardware/LVGL/GUI/lvgl/src/hal/: lv_hal_disp.c lv_hal_indev.c lv_hal_tick.c
  group lvgl/src/misc
    ../Hardware/LVGL/GUI/lvgl/src/misc/: lv_anim.c lv_anim_timeline.c lv_area.c lv_async.c lv_bidi.c lv_color.c lv_fs.c lv_gc.c lv_ll.c lv_log.c lv_lru.c lv_math.c lv_mem.c lv_printf.c lv_style.c lv_style_gen.c lv_templ.c lv_timer.c lv_tlsf.c lv_txt.c lv_txt_ap.c lv_utils.c
  group lvgl/src/widgets
    ../Hardware/LVGL/GUI/lvgl/src/widgets/: lv_arc.c lv_bar.c lv_btn.c lv_btnmatrix.c lv_canvas.c lv_checkbox.c lv_dropdown.c lv_img.c lv_label.c lv_line.c lv_objx_templ.c lv_roller.c lv_slider.c lv_switch.c lv_table.c lv_textarea.c
  group lvgl/GUI/APP
    ../Hardware/LVGL/GUI_APP/demos/stress/: lv_demo_stress.c
    ../Hardware/LVGL/GUI_APP/demos/music/: lv_demo_music.c lv_demo_music_list.c lv_demo_music_main.c
    ../Hardware/LVGL/GUI_APP/demos/music/assets/: img_lv_demo_music_btn_corner_large.c img_lv_demo_music_btn_list_pause.c img_lv_demo_music_btn_list_pause_large.c img_lv_demo_music_btn_list_play.c img_lv_demo_music_btn_list_play_large.c img_lv_demo_music_btn_loop.c img_lv_demo_music_btn_loop_large.c img_lv_demo_music_btn_next.c img_lv_demo_music_btn_next_large.c img_lv_demo_music_btn_pause.c img_lv_demo_music_btn_pause_large.c img_lv_demo_music_btn_play.c img_lv_demo_music_btn_play_large.c img_lv_demo_music_btn_prev.c img_lv_demo_music_btn_prev_large.c img_lv_demo_music_btn_rnd.c img_lv_demo_music_btn_rnd_large.c img_lv_demo_music_corner_left.c img_lv_demo_music_corner_left_large.c img_lv_demo_music_corner_right.c img_lv_demo_music_corner_right_large.c img_lv_demo_music_cover_1.c img_lv_demo_music_cover_1_large.c img_lv_demo_music_cover_2.c img_lv_demo_music_cover_2_large.c img_lv_demo_music_cover_3.c img_lv_demo_music_cover_3_large.c img_lv_demo_music_icon_1.c img_lv_demo_music_icon_1_large.c img_lv_demo_music_icon_2.c img_lv_demo_music_icon_2_large.c img_lv_demo_music_icon_3.c img_lv_demo_music_icon_3_large.c img_lv_demo_music_icon_4.c img_lv_demo_music_icon_4_large.c img_lv_demo_music_list_border.c img_lv_demo_music_list_border_large.c img_lv_demo_music_logo.c img_lv_demo_music_slider_knob.c img_lv_demo_music_slider_knob_large.c img_lv_demo_music_wave_bottom.c img_lv_demo_music_wave_bottom_large.c img_lv_demo_music_wave_top.c img_lv_demo_music_wave_top_large.c
software components: CMSIS:CORE 5.0.2, Compiler:Event Recorder 1.4.0
